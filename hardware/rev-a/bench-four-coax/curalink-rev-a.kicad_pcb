# Repository AngeloWhey/CuraLink (continued)

## KiCad design hardware/rev-a/bench-four-coax/curalink-rev-a.kicad_pcb (continued)

Schematic: afe_shared_1.kicad_sch, CuraLink afe_shared_1

Parts:
C1057: 10nF; C_0603_1608Metric; MPN C0603C103F3GACTU; LCSC C2167903
C1058, C1068: 4.7uF; C_0603_1608Metric; MPN GRM188Z71A475KE15D; LCSC C913474
C1059, C1061, C1063, C1065, C1067: 100nF; C_0603_1608Metric; MPN 0603B104K500NT; LCSC C30926
R1145: 5.1k; R_0402_1005Metric; MPN 0402WGF5101TCE; LCSC C25905
R1146: 22M; R_0402_1005Metric; MPN 0402WGF2205TCE; LCSC C407703
R1147: 1k; R_0402_1005Metric; MPN RT0402BRD071KL; LCSC C852624
R1148: 10k; R_0402_1005Metric; MPN RT0402BRD0710KL; LCSC C190095
R1149: 47; R_0402_1005Metric; MPN 0402WGF470JTCE; LCSC C25118
TP125, TP127: REF_PRE [DNP]; TestPoint_Pad_D1.0mm; not fitted
TP126: VMID [DNP]; TestPoint_Pad_D1.0mm; not fitted
U101, U103, U105, U109: TLV9004IRUCR; TLV_RUC14_X2QFN_2x2mm_NoEP; MPN TLV9004IRUCR; LCSC C2058192
U107: TLV9054IPWR; TSSOP-14_4.4x5mm_P0.65mm; MPN TLV9054IPWR; LCSC C2057744
U110, U112: TPD4E05U06DQAR; TPD4E05U06DQA_USON10_1x2.5mm; MPN TPD4E05U06DQAR; LCSC C138714

Connections:
AFE_SPARE_C: U109.7 (OUT_C), U109.8 (IN_C-)
AFE_SPARE_D: U109.12 (IN_D-), U109.13 (OUT_D)
AVDD_3V0: C1059.1, C1061.1, C1063.1, C1065.1, C1067.1, C1068.1, U101.3 (V+), U103.3 (V+), U105.3 (V+), U107.4 (V+), U109.3 (V+); also elsewhere on the board
FFC_CH1: U110.1; also elsewhere on the board
FFC_CH2: U110.2; also elsewhere on the board
FFC_CH3: U110.4; also elsewhere on the board
FFC_CH4: U110.5; also elsewhere on the board
FFC_REF: R1145.1, U112.1; also elsewhere on the board
GND: C1058.2, C1059.2, C1061.2, C1063.2, C1065.2, C1067.2, C1068.2, U101.10 (V-), U103.10 (V-), U105.10 (V-), U107.11 (V-), U109.10 (V-), U110.3, U110.8, U112.3, U112.8; also elsewhere on the board
REF_LIMIT: C1057.1, R1145.2
REF_MINUS: R1147.1, R1148.2, U109.1 (IN_A-)
REF_PLUS: C1057.2, R1146.1, U109.2 (IN_A+)
REF_PRE: R1148.1, TP125.1, TP127.1, U109.14 (OUT_A); also elsewhere on the board
VMID: C1058.1, R1146.2, R1147.2, R1149.2, TP126.1; also elsewhere on the board
VMID_BUF: R1149.1, U109.5 (IN_B-), U109.6 (OUT_B)
VMID_RAW: U109.4 (IN_B+), U109.9 (IN_C+), U109.11 (IN_D+); also elsewhere on the board

Notes on the sheet:
afe shared 1
Exact physical pin numbers; global net labels define connections. NC crosses are intentional.

Schematic: power_1.kicad_sch, CuraLink power_1

Parts:
D501: SS14; SS14_SMA_A1K2; MPN SS14; LCSC C83852
D502: BAT54C-7-F; SOT-23; MPN BAT54C-7-F; LCSC C134405
D503, D504, D507, D508, D509: BAT54-7-F; SOT-23; MPN BAT54-7-F; LCSC C106920
Q501, Q502: DMP2035U-7; SOT-23; MPN DMP2035U-7; LCSC C110499
Q503, Q504, Q505, Q506, Q507: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R501: 0 [DNP]; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189; not fitted
R502: 0; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
R503: 130k; R_0402_1005Metric; MPN RC0402FR-07130KL; LCSC C93946
R504: 15k; R_0402_1005Metric; MPN 0402WGF1502TCE; LCSC C25756
R505: 2k [DNP]; R_0402_1005Metric; MPN 0402WGF2001TCE; LCSC C4109; not fitted
R506, R508, R509, R512, R517: 10k; R_0402_1005Metric; MPN RT0402BRD0710KL; LCSC C190095
R507, R516, R518: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R510: 300k; R_0402_1005Metric; MPN 0402WGF3003TCE; LCSC C25774
R511, R513: 1Meg; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
R514: 510k; R_0402_1005Metric; MPN RC0402FR-07510KL; LCSC C137961
R515: 10Meg; R_0603_1608Metric; MPN RC0603FR-0710ML; LCSC C114606
U501: BQ25185DLHR; BQ25185DLH_WSON10_2.2x2mm; MPN BQ25185DLHR; LCSC C19725033
U502, U511: TPS25200DRVR; TPS25200DRV_WSON6_2x2mm; MPN TPS25200DRVR; LCSC C128401
U503, U512, U513: TPS7A2030PDBVR; SOT-23-5; MPN TPS7A2030PDBVR; LCSC C963429
U504, U505, U506, U507: TLV3012BIDBVR; SOT-23-6; MPN TLV3012BIDBVR; LCSC C20345924
U508, U510: 74LVC1G17GV,125; SOT-23-5; MPN 74LVC1G17GV,125; LCSC C6076
U509: SN74LVC1G04DBVR; SOT-23-5; MPN SN74LVC1G04DBVR; LCSC C7827

Connections:
AFE_ENABLE: U512.3 (EN); also elsewhere on the board
ANALOG_DISCHARGE: Q507.3 (D); also elsewhere on the board
AVDD_3V0: U512.5 (OUT); also elsewhere on the board
BAT_CHG: R501.2, U501.2 (BAT); also elsewhere on the board
BAT_OK: D503.3 (K), R515.1, U504.1 (OUT)
BAT_RUN: Q501.3 (D), R502.2
BAT_SENSE: R513.2, R514.1, R515.2, U504.3 (IN+); also elsewhere on the board
CELL_TEMP: U506.3 (IN+), U507.4 (IN-); also elsewhere on the board
CE_MID1: Q504.2 (S), Q505.3 (D)
CE_MID2: Q505.2 (S), Q506.3 (D)
CHARGE_DELAY: D508.1 (A), U510.2 (A); also elsewhere on the board
CHARGE_READY: Q504.1 (G), U510.4 (Y)
CHG_CE_N: Q504.3 (D), R507.2, U501.4 (CE_N); also elsewhere on the board
CHG_FAST_DISCH: D508.3 (K); also elsewhere on the board
CHG_IN: D502.2 (A2), U501.10 (IN), U502.1 (OUT); also elsewhere on the board
CHG_INPUT_FAULT_N: R512.2, U502.3 (FAULT_N)
CHG_ISET: R504.1, R505.1, U501.8 (ISET)
CHG_STAT1: R508.2, U501.9 (STAT1); also elsewhere on the board
CHG_STAT2: R509.2, U501.3 (STAT2); also elsewhere on the board
CHG_SYS: U501.1 (SYS); also elsewhere on the board
CHG_TS: R506.1, U501.6 (TS/MR)
CHG_VSET: R503.1, U501.7 (ILIM/VSET)
CTRL_3V0: R507.1, R512.1, U503.5 (OUT), U504.6 (V+), U505.6 (V+), U506.6 (V+), U507.6 (V+), U508.5 (VCC), U509.5 (VCC), U510.5 (VCC); also elsewhere on the board
CTRL_INPUT: D502.3 (K_COMMON), U503.1 (IN), U503.3 (EN); also elsewhere on the board
DVDD_3V0: R508.1, R509.1, U513.5 (OUT); also elsewhere on the board
FIELD_ABSENT: D504.3 (K), U505.1 (OUT); also elsewhere on the board
GND: D509.1 (A), Q503.2 (S), Q506.2 (S), Q507.2 (S), R503.2, R504.2, R506.2, R511.2, R514.2, R517.2, U501.5 (GND), U501.11 (EP_GND), U502.5 (GND), U502.7 (EP_GND), U503.2 (GND), U504.2 (V-), U505.2 (V-), U506.2 (V-), U507.2 (V-), U508.3 (GND), U509.3 (GND), U510.3 (GND), U511.5 (GND), U511.7 (EP_GND), U512.2 (GND), U513.2 (GND); also elsewhere on the board
ISET_COMP: R505.2; also elsewhere on the board
NOT_RUN: Q507.1 (G), U509.4 (Y); also elsewhere on the board
PACK+: D502.1 (A1), R501.1, R502.1, R513.1; also elsewhere on the board
PMOS_COMMON_SOURCE: Q501.2 (S), Q502.2 (S); also elsewhere on the board
REF_1V242: R518.1, U504.4 (IN-), U504.5 (REF); also elsewhere on the board
RUN_DELAY: D507.1 (A), U508.2 (A); also elsewhere on the board
RUN_ENABLE: Q503.1 (G), U508.4 (Y), U509.2 (A), U511.4 (EN); also elsewhere on the board
RUN_FAST_DISCH: D507.3 (K); also elsewhere on the board
RUN_PERMIT: D503.1 (A), D504.1 (A); also elsewhere on the board
SW_GATE: Q501.1 (G), Q502.1 (G); also elsewhere on the board
SW_GATE_PULL: Q503.3 (D); also elsewhere on the board
SYS_ANALOG_IN: U512.1 (IN); also elsewhere on the board
SYS_DIGITAL_IN: U513.1 (IN), U513.3 (EN); also elsewhere on the board
SYS_EF_ILIM: U511.2 (ILIM); also elsewhere on the board
SYS_FAULT_N: U511.3 (FAULT_N); also elsewhere on the board
SYS_PRE: Q502.3 (D), U511.6 (IN); also elsewhere on the board
TEMP_COLD_OK: Q505.1 (G), U506.1 (OUT)
TEMP_COLD_REF: U506.4 (IN-); also elsewhere on the board
TEMP_HOT_OK: Q506.1 (G), U507.1 (OUT)
TEMP_HOT_REF: U507.3 (IN+); also elsewhere on the board
WPT_EF_EN: R510.2, U502.4 (EN)
WPT_EF_ILIM: R511.1, U502.2 (ILIM)
WPT_PROTECTED: D501.2 (K), R510.1, U502.6 (IN); also elsewhere on the board
WPT_RAW: D501.1 (A), R516.1; also elsewhere on the board
WPT_SENSE: D509.3 (K), R516.2, R517.1, U505.4 (IN-); also elsewhere on the board
WPT_THRESHOLD: R518.2, U505.3 (IN+); also elsewhere on the board

Notes on the sheet:
power 1
Exact physical pin numbers; global net labels define connections. NC crosses are intentional.

Schematic: power_2.kicad_sch, CuraLink power_2

Parts:
C501, C502: 2.2uF 25V X7R; C_0805_2012Metric; MPN 0805B225K250NT; LCSC C74690
C503: 10uF 25V X7R; C_1206_3216Metric; MPN CL31B106KAHNNNE; LCSC C14860
C504, C506, C507, C523: 2.2uF 10V X7R; C_0603_1608Metric; MPN CL10B225KP8NNNC; LCSC C100082
C505: 4.7nF 50V C0G [DNP]; C_0603_1608Metric; MPN GRM1885C1H472JA01D; LCSC C85980
C508, C509, C510, C511, C515, C520, C521, C522: 100nF 10V X7R; C_0402_1005Metric; MPN 0402B104K160NT; LCSC C41851
C512: 4.7nF C0G; C_0603_1608Metric; MPN GRM1885C1H472JA01D; LCSC C85980
C513: 1nF C0G; C_0402_1005Metric; MPN 0402CG102J500NT; LCSC C53547
C514: 100pF C0G; C_0402_1005Metric; MPN 0402CG101J500NT; LCSC C1546
C516, C517: 10nF C0G; C_0603_1608Metric; MPN C0603C103F3GACTU; LCSC C2167903
C518: 2.2uF 16V X7R; C_0805_2012Metric; MPN CL21B225KOFNNNE; LCSC C28234
C519: 4.7uF 16V X7R; C_0805_2012Metric; MPN 0805B475K160NT; LCSC C880382
R519: 20k; R_0402_1005Metric; MPN 0402WGF2002TCE; LCSC C25765
R520: 1.5Meg; R_0402_1005Metric; MPN 0402WGF1504TCE; LCSC C22276
R521, R526, R535, R540, R541: 10k; R_0402_1005Metric; MPN RT0402BRD0710KL; LCSC C190095
R522: 113k; R_0402_1005Metric; MPN 0402WGF1133TCE; LCSC C25746
R523, R525, R531, R533: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R524: 66.5k; R_0402_1005Metric; MPN 0402WGF6652TCE; LCSC C29381
R527, R529: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
R528, R530, R532: 1k; R_0402_1005Metric; MPN RT0402BRD071KL; LCSC C852624
R534: 820k; R_0402_1005Metric; MPN 0402WGF8203TCE; LCSC C67558
R536, R537, R543: 0; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
R538, R539: 100; R_0603_1608Metric; MPN 0603WAF1000T5E; LCSC C22775
R542: 0 [DNP]; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189

Connections:
ANALOG_DISCHARGE: R538.2; also elsewhere on the board
AVDD_3V0: R538.1, R540.1; also elsewhere on the board
BAT_CHG: C504.1; also elsewhere on the board
BAT_SENSE: C513.1; also elsewhere on the board
BENCH_CHG_5V: R543.1; also elsewhere on the board
CELL_TEMP: C515.1, R521.1; also elsewhere on the board
CHARGE_DELAY: C519.1, R529.2; also elsewhere on the board
CHG_FAST_DISCH: R530.1; also elsewhere on the board
CHG_IN: C502.1; also elsewhere on the board
CHG_SYS: C503.1; also elsewhere on the board
CTRL_3V0: C507.1, C508.1, C509.1, C510.1, C511.1, C520.1, C521.1, C522.1, R526.1, R535.1; also elsewhere on the board
CTRL_INPUT: C506.1; also elsewhere on the board
FIELD_ABSENT: R520.1; also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, R519.2, R521.2, R523.2, R525.2, R533.2, R534.2, R541.2; also elsewhere on the board
ISET_COMP: C505.1; also elsewhere on the board
NOT_RUN: R529.1, R530.2; also elsewhere on the board
PMOS_COMMON_SOURCE: R531.1; also elsewhere on the board
REF_1V242: C512.1, R522.1, R524.1; also elsewhere on the board
RUN_DELAY: C518.1, R527.2; also elsewhere on the board
RUN_ENABLE: R533.1; also elsewhere on the board
RUN_FAST_DISCH: R528.1; also elsewhere on the board
RUN_PERMIT: R526.2, R527.1, R528.2; also elsewhere on the board
SW_GATE: R531.2, R532.1; also elsewhere on the board
SW_GATE_PULL: R532.2; also elsewhere on the board
SYS_ANALOG_IN: R536.2; also elsewhere on the board
SYS_DIGITAL_IN: R537.2; also elsewhere on the board
SYS_EF_ILIM: R534.1; also elsewhere on the board
SYS_FAULT_N: R535.2; also elsewhere on the board
SYS_PRE: C523.1; also elsewhere on the board
TEMP_COLD_REF: C516.1, R522.2, R523.1; also elsewhere on the board
TEMP_HOT_REF: C517.1, R524.2, R525.1; also elsewhere on the board
VMID_RAW: R540.2, R541.1; also elsewhere on the board
WPT_PROTECTED: C501.1; also elsewhere on the board
WPT_RAW: R542.2, R543.2; also elsewhere on the board
WPT_RX_DC: R542.1; also elsewhere on the board
WPT_SENSE: C514.1; also elsewhere on the board
WPT_THRESHOLD: R519.1, R520.2; also elsewhere on the board

Notes on the sheet:
power 2
Exact physical pin numbers; global net labels define connections. NC crosses are intentional.

Schematic: power_3.kicad_sch, CuraLink power_3

Parts:
C524, C528: 10uF 10V X7R; C_0805_2012Metric; MPN CL21B106KOQNNNE; LCSC C95841
C525, C527, C529: 2.2uF 10V X7R; C_0603_1608Metric; MPN CL10B225KP8NNNC; LCSC C100082
C526: 4.7uF 10V X7R; C_0603_1608Metric; MPN 0603B475K100NT; LCSC C108342
C530: 100nF 10V X7R [DNP]; C_0402_1005Metric; MPN 0402B104K160NT; LCSC C41851
C531: 100pF C0G; C_0402_1005Metric; MPN 0402CG101J500NT; LCSC C1546
C532: 100nF 10V X7R; C_0402_1005Metric; MPN 0402B104K160NT; LCSC C41851
J501: Protected pack + external cell NTC; CopperField_4P_P2mm_D0.9mm; MPN PCB copper
J502: WPT receiver DC input [DNP]; CopperField_2P_P2mm_D0.9mm; MPN PCB copper
J503: Bench charge input 5V; CopperField_2P_P2mm_D0.9mm; MPN PCB copper
J504: Bare cell only — PCM qualification required [DNP]; CopperField_2P_P2mm_D0.9mm; MPN PCB copper
Q509, Q510: AO3400A [DNP]; SOT-23; MPN AO3400A; LCSC C20917
R544, R545: 0 [DNP]; R_0603_1608Metric; MPN 0603WAF0000T5E; LCSC C21189
R546: 1.0 [DNP]; R_0805_2012Metric; MPN RC0805FR-071RL; LCSC C131397
R547: 330 [DNP]; R_0603_1608Metric; MPN 0603WAF3300T5E; LCSC C23138
R548: 2.2k [DNP]; R_0603_1608Metric; MPN 0603WAF2201T5E; LCSC C4190
R549: 200k; R_0603_1608Metric; MPN 0603WAF2003T5E; LCSC C25811
R550: 1Meg; R_0402_1005Metric; MPN 0402WGF1004TCE; LCSC C26083
R551: 6.04Meg; R_0603_1608Metric; MPN 0603WAF6044T5E; LCSC C422914
RT501: 10k B3435 NTC; CopperField_2P_P2mm_D0.9mm; MPN MF52D103F3435L100; LCSC C5439722
U514: BQ29737DSER [DNP]; BQ29737DSE_WSON6_1.5x1.5mm; MPN BQ29737DSER; LCSC C3681751
U515: TLV3012BIDBVR; SOT-23-6; MPN TLV3012BIDBVR; LCSC C20345924

Connections:
AVDD_3V0: C526.1, R544.2; also elsewhere on the board
BENCH_CHG_5V: J503.1 (DVDD); also elsewhere on the board
CELLN: C530.2, J504.2 (BOOT0), Q509.2 (S), U514.4 (VSS)
CELLP: J504.1 (DVDD), R545.1, R547.1
CELL_TEMP: J501.4 (VTREF_SENSE_ONLY), RT501.2; also elsewhere on the board
CTRL_3V0: C532.1, U515.6 (V+); also elsewhere on the board
DIGITAL_GOOD: R551.1, U515.1 (OUT); also elsewhere on the board
DIGITAL_SENSE: C531.1, R549.2, R550.1, R551.2, U515.3 (IN+)
DVDD_3V0: C528.1, R544.1, R549.1; also elsewhere on the board
GND: C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C531.2, C532.2, J501.2 (TARGET_TX), J502.2 (BOOT0), J503.2 (BOOT0), R546.2, R548.1, R550.2, U515.2 (V-); also elsewhere on the board
PACK+: J501.1 (GND), R545.2; also elsewhere on the board
PCM_BAT: C530.1, R547.2, U514.5 (BAT)
PCM_CHG_GATE: Q510.1 (G), U514.2 (COUT)
PCM_COMMON_DRAIN: Q509.3 (D), Q510.3 (D)
PCM_DSG_GATE: Q509.1 (G), U514.3 (DOUT)
PCM_NEG_SENSE: Q510.2 (S), R546.1
PCM_VMINUS: R548.2, U514.6 (V-)
REF_1V242: J501.3 (TARGET_RX), RT501.1, U515.4 (IN-); also elsewhere on the board
SYS_ANALOG_IN: C525.1; also elsewhere on the board
SYS_DIGITAL_IN: C527.1; also elsewhere on the board
VMID_RAW: C529.1; also elsewhere on the board
WPT_RX_DC: J502.1 (DVDD); also elsewhere on the board

Notes on the sheet:
power 3
Exact physical pin numbers; global net labels define connections. NC crosses are intentional.

Schematic: four-inputs.kicad_sch, Four coaxial generator inputs

Parts:
J601: CH1 U.FL; UFL_Hirose_1SIG_2GND_3GND; MPN U.FL-R-SMT-1(80); LCSC C88374
J602: CH2 U.FL; UFL_Hirose_1SIG_2GND_3GND; MPN U.FL-R-SMT-1(80); LCSC C88374
J603: CH3 U.FL; UFL_Hirose_1SIG_2GND_3GND; MPN U.FL-R-SMT-1(80); LCSC C88374
J604: CH4 U.FL; UFL_Hirose_1SIG_2GND_3GND; MPN U.FL-R-SMT-1(80); LCSC C88374
R601, R602, R603, R604, R605: 47k 1%; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792

Connections:
/Four coax inputs/COAX_CH1: J601.1 (CONTACT), R601.1
/Four coax inputs/COAX_CH2: J602.1 (CONTACT), R602.1
/Four coax inputs/COAX_CH3: J603.1 (CONTACT), R603.1
/Four coax inputs/COAX_CH4: J604.1 (CONTACT), R604.1
FFC_CH1: R601.2; also elsewhere on the board
FFC_CH2: R602.2; also elsewhere on the board
FFC_CH3: R603.2; also elsewhere on the board
FFC_CH4: R604.2; also elsewhere on the board
FFC_REF: R605.2; also elsewhere on the board
GND: J601.2 (SHELL), J601.3 (SHELL), J602.2 (SHELL), J602.3 (SHELL), J603.2 (SHELL), J603.3 (SHELL), J604.2 (SHELL), J604.3 (SHELL), R605.1; also elsewhere on the board

Notes on the sheet:
Four independent benchtop waveform inputs
Board-edge coax / local 47 k source model / protected AFE input
Place each series resistor beside the protected AFE input. Keep all coax shields on local GND.
Existing FFC_* net names identify the AFE boundary. There is no FFC connector in this variant.

Schematic: charge-telemetry.kicad_sch, Radio power and charger status

Parts:
C610: 100nF 10V X7R; C_0402_1005Metric; MPN 0402B104K160NT; LCSC C41851
D610, D611: SS14; SS14_SMA_A1K2; MPN SS14; LCSC C83852
Q610, Q611: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R610, R611: 10k; R_0402_1005Metric; MPN RT0402BRD0710KL; LCSC C190095
U610: 74LVC1G08GV,125; SOT-23-5; MPN 74LVC1G08GV,125; LCSC C282347

Connections:
AFE_ENABLE: U610.4 (Y); also elsewhere on the board
CHG_CE_N: Q611.1 (G); also elsewhere on the board
CHG_ENABLED_MCU: Q611.3 (D), R611.2; also elsewhere on the board
CHG_IN: D611.1 (A); also elsewhere on the board
CTRL_3V0: C610.1, U610.5 (VCC); also elsewhere on the board
DIGITAL_GOOD: U610.2 (A); also elsewhere on the board
DVDD_3V0: R610.1, R611.1; also elsewhere on the board
FIELD_ABSENT: Q610.1 (G); also elsewhere on the board
GND: C610.2, Q610.2 (S), Q611.2 (S), U610.3 (GND); also elsewhere on the board
RUN_ENABLE: U610.1 (B); also elsewhere on the board
RX_DC_PRESENT_MCU: Q610.3 (D), R610.2; also elsewhere on the board

Notes on the sheet:
MCU supply during charging and AFE interlock
Full net labels connect to the power, MCU and control sheets.

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
Board: 4 copper layers, 326 parts (0 on the bottom side), 193 nets, no tracks yet.

File hardware/rev-a/bench-four-coax/assembly-bom.csv:

References,Quantity,Value,MPN,LCSC,Populate,Assembly
"R501,R542,R545",3,0,0603WAF0000T5E,C21189,DNP,PCB_SMT
"R502,R536,R537,R543",4,0,0603WAF0000T5E,C21189,FIT,PCB_SMT
R417,1,0ohm,0402WGF0000TCE,C17168,FIT,PCB_SMT
R418,1,0ohm DNP,0402WGF0000TCE,C17168,DNP,PCB_SMT
R612,1,0ohm antenna initial,0402WGF0000TCE,C17168,FIT,PCB_SMT
R546,1,1.0,RC0805FR-071RL,C131397,DNP,PCB_SMT
R520,1,1.5Meg,0402WGF1504TCE,C22276,FIT,PCB_SMT
"R1014,R1032,R1050,R1068",4,1.5k,RT0402BRD071K5L,C281775,FIT,PCB_SMT
R538,1,100,0603WAF1000T5E,C22775,FIT,PCB_SMT
"R507,R516,R518,R523,R525,R531,R533",7,100k,0402WGF1003TCE,C25741,FIT,PCB_SMT
R409,1,100kohm 1%,0402WGF1003TCE,C25741,FIT,PCB_SMT
"C1059,C1061,C1063,C1065,C1067",5,100nF,0603B104K500NT,C30926,FIT,PCB_SMT
C530,1,100nF 10V X7R,0402B104K160NT,C41851,DNP,PCB_SMT
"C508,C509,C510,C511,C515,C520,C521,C522,C532,C610",10,100nF 10V X7R,0402B104K160NT,C41851,FIT,PCB_SMT
"C401,C402,C403,C404,C406,C410,C411,C412",8,100nF X7R >=10V,GRM155R71C104KA88D,C71629,FIT,PCB_SMT
"C514,C531",2,100pF C0G,0402CG101J500NT,C1546,FIT,PCB_SMT
R515,1,10Meg,RC0603FR-0710ML,C114606,FIT,PCB_SMT
"R1004,R1013,R1017,R1022,R1031,R1035,R1040,R1049,R1053,R1058,R1067,R1071,R1148,R506,R508,R509,R512,R517,R521,R526,R535,R540,R541,R610,R611",25,10k,RT0402BRD0710KL,C190095,FIT,PCB_SMT
RT501,1,10k B3435 NTC,MF52D103F3435L100,C5439722,FIT,OFFBOARD_MANUAL
R410,1,10kohm 1%,RT0402BRD0710KL,C190095,FIT,PCB_SMT
"C1001,C1002,C1003,C1008,C1009,C1010,C1015,C1016,C1017,C1022,C1023,C1024,C1057",13,10nF,C0603C103F3GACTU,C2167903,FIT,PCB_SMT
"C516,C517",2,10nF C0G,C0603C103F3GACTU,C2167903,FIT,PCB_SMT
"C524,C528",2,10uF 10V X7R,CL21B106KOQNNNE,C95841,FIT,PCB_SMT
C503,1,10uF 25V X7R,CL31B106KAHNNNE,C14860,FIT,PCB_SMT
C405,1,10uF X5R >=10V,CL10A106KP8NNNC,C19702,FIT,PCB_SMT
R522,1,113k,0402WGF1133TCE,C25746,FIT,PCB_SMT
"R1018,R1036,R1054,R1072",4,12.4k,RT0402BRD0712K4L,C723611,FIT,PCB_SMT
R503,1,130k,RC0402FR-07130KL,C93946,FIT,PCB_SMT
"R401,R402,R403,R404",4,150ohm 0.1%,RT0402BRD07150RL,C852539,FIT,PCB_SMT
R504,1,15k,0402WGF1502TCE,C25756,FIT,PCB_SMT
"R511,R513,R550",3,1Meg,0402WGF1004TCE,C26083,FIT,PCB_SMT
R416,1,1Mohm 1%,0402WGF1004TCE,C26083,FIT,PCB_SMT
"R1003,R1021,R1039,R1057,R1147,R528,R530,R532",8,1k,RT0402BRD071KL,C852624,FIT,PCB_SMT
"C1004,C1005,C1006,C1007,C1011,C1012,C1013,C1014,C1018,C1019,C1020,C1021,C1025,C1026,C1027,C1028",16,1nF,0603CG102F500NT,C507408,FIT,PCB_SMT
C513,1,1nF C0G,0402CG102J500NT,C53547,FIT,PCB_SMT
C407,1,1uF X7R >=10V,CL10B105KO8NNNC,C59782,FIT,PCB_SMT
R548,1,2.2k,0603WAF2201T5E,C4190,DNP,PCB_SMT
"C504,C506,C507,C523,C525,C527,C529",7,2.2uF 10V X7R,CL10B225KP8NNNC,C100082,FIT,PCB_SMT
C518,1,2.2uF 16V X7R,CL21B225KOFNNNE,C28234,FIT,PCB_SMT
"C501,C502",2,2.2uF 25V X7R,0805B225K250NT,C74690,FIT,PCB_SMT
AE401,1,2.45GHz chip antenna,2450AT18D0100001E,C7450310,FIT,PCB_SMT
R549,1,200k,0603WAF2003T5E,C25811,FIT,PCB_SMT
R519,1,20k,0402WGF2002TCE,C25765,FIT,PCB_SMT
"R1011,R1012,R1015,R1016,R1029,R1030,R1033,R1034,R1047,R1048,R1051,R1052,R1065,R1066,R1069,R1070",16,22.6k,0402WGF2262TCE,C26960,FIT,PCB_SMT
"R1002,R1020,R1038,R1056,R1146",5,22M,0402WGF2205TCE,C407703,FIT,PCB_SMT
R505,1,2k,0402WGF2001TCE,C4109,DNP,PCB_SMT
R510,1,300k,0402WGF3003TCE,C25774,FIT,PCB_SMT
Y402,1,32.768kHz / CL6pF,NX3215SA 32.768KHZ EXS00A-MU00525,C528987,FIT,PCB_SMT
Y401,1,32MHz / CL8pF,NX2016SA-32MHZ-STD-CZS-5,C843260,FIT,PCB_SMT
R547,1,330,0603WAF3300T5E,C23138,DNP,PCB_SMT
C505,1,4.7nF 50V C0G,GRM1885C1H472JA01D,C85980,DNP,PCB_SMT
C512,1,4.7nF C0G,GRM1885C1H472JA01D,C85980,FIT,PCB_SMT
"C421,C422",2,4.7pF C0G +/-0.25pF 50V,0402CG4R7C500NT,C1569,FIT,PCB_SMT
"C1058,C1068",2,4.7uF,GRM188Z71A475KE15D,C913474,FIT,PCB_SMT
C526,1,4.7uF 10V X7R,GRM188Z71A475KE15D,C913474,FIT,PCB_SMT
C519,1,4.7uF 16V X7R,0805B475K160NT,C880382,FIT,PCB_SMT
C408,1,4.7uF X5R >=10V,CL10A475KP8NNNC,C1705,FIT,PCB_SMT
R1149,1,47,0402WGF470JTCE,C25118,FIT,PCB_SMT
C409,1,470nF X7R >=10V,CL10B474KA8NNNC,C1623,FIT,PCB_SMT
"C413,C414,C415,C416",4,470pF C0G 5% 50V,0402CG471J500NT,C75274,FIT,PCB_SMT
"R527,R529",2,47k,0402WGF4702TCE,C25792,FIT,PCB_SMT
"R601,R602,R603,R604,R605",5,47k 1%,0402WGF4702TCE,C25792,FIT,PCB_SMT
"R411,R412,R413,R414,R415",5,47ohm 1%,0402WGF470JTCE,C25118,FIT,PCB_SMT
"R1001,R1019,R1037,R1055,R1145",5,5.1k,0402WGF5101TCE,C25905,FIT,PCB_SMT
"R1005,R1008,R1023,R1026,R1041,R1044,R1059,R1062",8,51.1k,RT0402BRD0751K1L,C852827,FIT,PCB_SMT
R514,1,510k,RC0402FR-07510KL,C137961,FIT,PCB_SMT
R551,1,6.04Meg,0603WAF6044T5E,C422914,FIT,PCB_SMT
R524,1,66.5k,0402WGF6652TCE,C29381,FIT,PCB_SMT
U610,1,"74LVC1G08GV,125","74LVC1G08GV,125",C282347,FIT,PCB_SMT
"U508,U510",2,"74LVC1G17GV,125","74LVC1G17GV,125",C6076,FIT,PCB_SMT
R534,1,820k,0402WGF8203TCE,C67558,FIT,PCB_SMT
"R1006,R1007,R1009,R1010,R1024,R1025,R1027,R1028,R1042,R1043,R1045,R1046,R1060,R1061,R1063,R1064",16,910k,ARG03BTC9103,C2686431,FIT,PCB_SMT
"Q509,Q510",2,AO3400A,AO3400A,C20917,DNP,PCB_SMT
"Q503,Q504,Q505,Q506,Q507,Q610,Q611",7,AO3400A,AO3400A,C20917,FIT,PCB_SMT
"D503,D504,D507,D508,D509",5,BAT54-7-F,BAT54-7-F,C106920,FIT,PCB_SMT
D502,1,BAT54C-7-F,BAT54C-7-F,C134405,FIT,PCB_SMT
U501,1,BQ25185DLHR,BQ25185DLHR,C19725033,FIT,PCB_SMT
U514,1,BQ29737DSER,BQ29737DSER,C3681751,DNP,PCB_SMT
J601,1,CH1 U.FL,U.FL-R-SMT-1(80),C88374,FIT,PCB_SMT
J602,1,CH2 U.FL,U.FL-R-SMT-1(80),C88374,FIT,PCB_SMT
J603,1,CH3 U.FL,U.FL-R-SMT-1(80),C88374,FIT,PCB_SMT
J604,1,CH4 U.FL,U.FL-R-SMT-1(80),C88374,FIT,PCB_SMT
"Q501,Q502",2,DMP2035U-7,DMP2035U-7,C110499,FIT,PCB_SMT
"C613,C614",2,DNP antenna shunt,,,DNP,PCB_SMT
U402,1,MLPF-WB-04D3,MLPF-WB-04D3,C22378853,FIT,PCB_SMT
U509,1,SN74LVC1G04DBVR,SN74LVC1G04DBVR,C7827,FIT,PCB_SMT
"D501,D610,D611",3,SS14,SS14,C83852,FIT,PCB_SMT
U401,1,STM32WBA52CEU6,STM32WBA52CEU6,C7543271,FIT,PCB_SMT
"U504,U505,U506,U507,U515",5,TLV3012BIDBVR,TLV3012BIDBVR,C20345924,FIT,PCB_SMT
"U101,U103,U105,U109",4,TLV9004IRUCR,TLV9004IRUCR,C2058192,FIT,PCB_SMT
U107,1,TLV9054IPWR,TLV9054IPWR,C2057744,FIT,PCB_SMT
"U110,U112",2,TPD4E05U06DQAR,TPD4E05U06DQAR,C138714,FIT,PCB_SMT
"U502,U511",2,TPS25200DRVR,TPS25200DRVR,C128401,FIT,PCB_SMT
"U503,U512,U513",3,TPS7A2030PDBVR,TPS7A2030PDBVR,C963429,FIT,PCB_SMT
J404,1,U.FL RF test DNP,U.FL-R-SMT-1(80),C88374,DNP,PCB_SMT
